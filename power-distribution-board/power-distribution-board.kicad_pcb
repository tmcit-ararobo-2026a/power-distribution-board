# Repository tmcit-ararobo-2026a/power-distribution-board

## KiCad design power-distribution-board/power-distribution-board.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9: 1000uf; CP_Radial_D16.0mm_P7.50mm
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J3, J4, J5, J6, J7: Conn_01x02; AMASS_XT60-F_1x02_P7.20mm_Vertical
J8: Conn_01x02; AMASS_XT60-M_1x02_P7.20mm_Vertical
R1: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, R1.2
unnamed: D1.1 (K), R1.1
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, D1.2 (A), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2

Notes on the sheet:
ESC分岐用端子
電源入出力
LED

Board: 2 copper layers, 90.0 x 70.0 mm, 19 parts (0 on the bottom side), 3 nets.

File power-distribution-board/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C5, C6, C7, C8, C9",CP_Radial_D16.0mm_P7.50mm,9,1000uf,
D1,0603,1,LED,
"J1, J2, J3, J4, J5, J6, J7",AMASS_XT60-F_1x02_P7.20mm_Vertical,7,Conn_01x02,
J8,AMASS_XT60-M_1x02_P7.20mm_Vertical,1,Conn_01x02,
R1,0603,1,1k,

## Commit log

2026-03-26 ビア打ち以外完成
2026-04-02 ガーバー
2026-04-25 ±の反転を修正 ガーバ生成
